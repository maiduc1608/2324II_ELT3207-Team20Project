# Keil uVision project PWM_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F410C8Tx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: PWM_test.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
